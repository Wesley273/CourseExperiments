CIRCUIT EXP7_5
VS 1 0 DC 10V
R1 1 2 1
R2 2 4 2
R3 4 0 3
R4 3 2 4
R5 3 0 6
R6 4 3 10
.SENS V(2)
